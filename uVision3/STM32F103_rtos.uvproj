# Keil uVision project STM32F103_rtos.uvproj, settings and files
target BOOT_FLASH (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_RtosFlash +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: VECT_TAB_FLAS,ARM_MATH_CM3
  c include: ..\driver\inc;..\library\inc;..\os;..\startup;..\user;..\user\mpu
  asm define: ARM_MATH_CM3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../startup/: cortexm3_macro.s stm32f10x_it.c stm32f10x_startup.s stm32f10x_target.c
  group Library
    ../library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_tim1.c
  group uC/OS-II
    ../os/: os_cpu_a.s os_cpu_c.c os_dbg.c ucos_ii.c
  group Driver
    ../driver/src/: uart.c
  group User
    ../user/: main.c create_task.c detect.c rf.c display.c motor_hal.c kdebug.c hoover_disp.c pcf8563.c tm1637.c Function.c
  group mpu
    ../user/mpu/: inv_mpu_dmp_motion_driver.c inv_mpu.c mpu6050.c mpuiic.c
